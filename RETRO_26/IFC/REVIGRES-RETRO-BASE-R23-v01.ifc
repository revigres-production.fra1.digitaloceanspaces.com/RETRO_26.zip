Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [ContentGUID: , VersionGUID: e40072aa-ca77-4a87-944a-f4769d40ba70, NumberOfSaves: 19], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal], ExchangeRequirement [Architecture]
File name: REVIGRES-RETRO-BASE-R23-v01.ifc
Time: 2026-06-15T09:51:06+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.70.22 (ENU) - IFC 23.4.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1

# IfcCovering: Basic Wall:REVIGRES-RETRO-BASE-20x40-BRILHO-ALLOY, Basic Wall:REVIGRES-RETRO-BASE-20x40-BRILHO-ALLOY:9726
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 3100C90G61
Type - Pset_EnvironmentalImpactIndicators - Reference: 3100C90G61
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-RETRO-BASE-30x60-BRILHO-ALLOY
Pset_CoveringCommon - IsExternal: no
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Retro; NumeroGlobalDeItemComercial: 3100210G61; Acabamento: NAT; Material: Revestimento cerâmico vidrado; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/retro; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.3% máx.± 1.5 mm; Ortogonalidade: ± 0.3% máx.± 2.0 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 16% - 19%; ModuloDeRuptura: > 15 N/mm²; ResistenciaAFlexao: > 600 N; ResistenciaAFendilhagem: Resiste; ResistenciaAsManchas: Class 4; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 2; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 9.4 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - ItemEParcialmenteReciclado: 0; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaElectricaExportada: 1.55; EnergiaTermicaExportada: 0; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-RETRO-BASE-30X60-BRILHO-ALLOY; TipoProduto: Prensado a Seco: Grupo BIII GL | Revestimento cerâmico vidrado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-RETRO-BASE-20x40-BRILHO-AQUA, Basic Wall:REVIGRES-RETRO-BASE-20x40-BRILHO-AQUA:9759
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 3100C90G41
Type - Pset_EnvironmentalImpactIndicators - Reference: 3100C90G41
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-RETRO-BASE-30x60-BRILHO-AQUA
Pset_CoveringCommon - IsExternal: no
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Retro; NumeroGlobalDeItemComercial: 3100210G41; Acabamento: NAT; Material: Revestimento cerâmico vidrado; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/retro; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 16% - 19%; ModuloDeRuptura: > 15 N/mm²; ResistenciaAFlexao: > 600 N; ResistenciaAFendilhagem: Resiste; ResistenciaAsManchas: Class 4; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 2; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 9.4 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - ItemEParcialmenteReciclado: 0; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaElectricaExportada: 1.55; EnergiaTermicaExportada: 0; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-RETRO-BASE-30X60-BRILHO-AQUA; TipoProduto: Prensado a Seco: Grupo BIII GL | Revestimento cerâmico vidrado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-RETRO-BASE-20x40-BRILHO-BEGE, Basic Wall:REVIGRES-RETRO-BASE-20x40-BRILHO-BEGE:9760
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 3100C90G01
Type - Pset_EnvironmentalImpactIndicators - Reference: 3100C90G01
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-RETRO-BASE-30x60-BRILHO-BEGE
Pset_CoveringCommon - IsExternal: no
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Retro; NumeroGlobalDeItemComercial: 3100210G01; Acabamento: NAT; Material: Revestimento cerâmico vidrado; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/retro; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 16% - 19%; ModuloDeRuptura: > 15 N/mm²; ResistenciaAFlexao: > 600 N; ResistenciaAFendilhagem: Resiste; ResistenciaAsManchas: Class 4; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 2; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 9.4 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - ItemEParcialmenteReciclado: 0; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaElectricaExportada: 1.55; EnergiaTermicaExportada: 0; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-RETRO-BASE-30X60-BRILHO-BEGE; TipoProduto: Prensado a Seco: Grupo BIII GL | Revestimento cerâmico vidrado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-RETRO-BASE-20x40-BRILHO-BLUE, Basic Wall:REVIGRES-RETRO-BASE-20x40-BRILHO-BLUE:9761
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 3100C90G51
Type - Pset_EnvironmentalImpactIndicators - Reference: 3100C90G51
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-RETRO-BASE-30x60-BRILHO-BLUE
Pset_CoveringCommon - IsExternal: no
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Retro; NumeroGlobalDeItemComercial: 3100210G51; Acabamento: NAT; Material: Revestimento cerâmico vidrado; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/retro; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 16% - 19%; ModuloDeRuptura: > 15 N/mm²; ResistenciaAFlexao: > 600 N; ResistenciaAFendilhagem: Resiste; ResistenciaAsManchas: Class 4; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 2; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 9.4 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - ItemEParcialmenteReciclado: 0; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaElectricaExportada: 1.55; EnergiaTermicaExportada: 0; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-RETRO-BASE-30X60-BRILHO-BLUE; TipoProduto: Prensado a Seco: Grupo BIII GL | Revestimento cerâmico vidrado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-RETRO-BASE-20x40-BRILHO-CARMIM, Basic Wall:REVIGRES-RETRO-BASE-20x40-BRILHO-CARMIM:9762
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 3100C9G981
Type - Pset_EnvironmentalImpactIndicators - Reference: 3100C9G981
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-RETRO-BASE-30x60-BRILHO-CARMIM
Pset_CoveringCommon - IsExternal: no
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Retro; NumeroGlobalDeItemComercial: 310021G981; Acabamento: NAT; Material: Revestimento cerâmico vidrado; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/retro; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 16% - 19%; ModuloDeRuptura: > 15 N/mm²; ResistenciaAFlexao: > 600 N; ResistenciaAFendilhagem: Resiste; ResistenciaAsManchas: Class 4; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 2; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 9.4 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - ItemEParcialmenteReciclado: 0; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaElectricaExportada: 1.55; EnergiaTermicaExportada: 0; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-RETRO-BASE-30X60-BRILHO-CARMIM; TipoProduto: Prensado a Seco: Grupo BIII GL | Revestimento cerâmico vidrado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-RETRO-BASE-20x40-BRILHO-MUSTARD, Basic Wall:REVIGRES-RETRO-BASE-20x40-BRILHO-MUSTARD:2486
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 3100C90G31
Type - Pset_EnvironmentalImpactIndicators - Reference: 3100C90G31
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-RETRO-BASE-30x60-BRILHO-MUSTARD
Pset_CoveringCommon - IsExternal: no
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Retro; NumeroGlobalDeItemComercial: 3100210G31; Acabamento: NAT; Material: Revestimento cerâmico vidrado; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/retro; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 16% - 19%; ModuloDeRuptura: > 15 N/mm²; ResistenciaAFlexao: > 600 N; ResistenciaAFendilhagem: Resiste; ResistenciaAsManchas: Class 4; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 2; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 9.4 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - ItemEParcialmenteReciclado: 0; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; EnergiaTermicaExportada: 0; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-RETRO-BASE-30X60-BRILHO-MUSTARD; TipoProduto: Prensado a Seco: Grupo BIII GL | Revestimento cerâmico vidrado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-RETRO-BASE-20x40-BRILHO-OLIVE, Basic Wall:REVIGRES-RETRO-BASE-20x40-BRILHO-OLIVE:9328
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 3100C90G21
Type - Pset_EnvironmentalImpactIndicators - Reference: 3100C90G21
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-RETRO-BASE-30x60-BRILHO-OLIVE
Pset_CoveringCommon - IsExternal: no
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Retro; NumeroGlobalDeItemComercial: 3100210G21; Acabamento: NAT; Material: Revestimento cerâmico vidrado; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/retro; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 16% - 19%; ModuloDeRuptura: > 15 N/mm²; ResistenciaAFlexao: > 600 N; ResistenciaAFendilhagem: Resiste; ResistenciaAsManchas: Class 4; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 2; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 9.4 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - ItemEParcialmenteReciclado: 0; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaElectricaExportada: 1.55; EnergiaTermicaExportada: 0; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-RETRO-BASE-30X60-BRILHO-OLIVE; TipoProduto: Prensado a Seco: Grupo BIII GL | Revestimento cerâmico vidrado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-RETRO-BASE-20x40-BRILHO-ROSE, Basic Wall:REVIGRES-RETRO-BASE-20x40-BRILHO-ROSE:9419
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 3100C90G11
Type - Pset_EnvironmentalImpactIndicators - Reference: 3100C90G11
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-RETRO-BASE-30x60-BRILHO-ROSE
Pset_CoveringCommon - IsExternal: no
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Retro; NumeroGlobalDeItemComercial: 3100210G11; Acabamento: NAT; Material: Revestimento cerâmico vidrado; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/retro; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 16% - 19%; ModuloDeRuptura: > 15 N/mm²; ResistenciaAFlexao: > 600 N; ResistenciaAFendilhagem: Resiste; ResistenciaAsManchas: Class 4; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 2; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 9.4 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - ItemEParcialmenteReciclado: 0; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaElectricaExportada: 1.55; EnergiaTermicaExportada: 0; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-RETRO-BASE-30X60-BRILHO-ROSE; TipoProduto: Prensado a Seco: Grupo BIII GL | Revestimento cerâmico vidrado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-RETRO-BASE-20x40-BRILHO-WHITE, Basic Wall:REVIGRES-RETRO-BASE-20x40-BRILHO-WHITE:9498
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 3100C9G991
Type - Pset_EnvironmentalImpactIndicators - Reference: 3100C9G991
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-RETRO-BASE-30x60-BRILHO-WHITE
Pset_CoveringCommon - IsExternal: no
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Retro; NumeroGlobalDeItemComercial: 310021G991; Acabamento: NAT; Material: Revestimento cerâmico vidrado; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/retro; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 16% - 19%; ModuloDeRuptura: > 15 N/mm²; ResistenciaAFlexao: > 600 N; ResistenciaAFendilhagem: Resiste; ResistenciaAsManchas: Class 4; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 2; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 9.4 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - ItemEParcialmenteReciclado: 0; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaElectricaExportada: 1.55; EnergiaTermicaExportada: 0; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-RETRO-BASE-30X60-BRILHO-WHITE; TipoProduto: Prensado a Seco: Grupo BIII GL | Revestimento cerâmico vidrado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
